# Keil uVision project Project.uvprojx, settings and files
target py32f002b_qmi8656_jacdac_clean_hybrid_phy_build (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: py32f002b_qmi8656_jacdac_clean_hybrid_phy_build +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Bx5
  c include: ..\Inc;..\third_party\jacdac-c;..\third_party\jacdac-c\inc;..\third_party\jacdac-c\services;..\third_party\py32f002b-firmware\Drivers\BSP\PY32F002Bxx_Start_Kit;..\third_party\py32f002b-firmware\Drivers\CMSIS\Include;..\third_party\py32f002b-firmware\Drivers\CMSIS\Device\PY32F0xx\Include;..\third_party\py32f002b-firmware\Drivers\PY32F002B_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ./: startup_py32f002bxx.s
    ../Src/: system_py32f002b.c
  group Application/User
    ../Src/: main.c qmi8656_probe.c py32f002b_hal_msp.c py32f002b_it.c py32_jacdac_runtime.c py32_qmi8656_jacdac_services.c py32_rgb_pwm_backend.c
    ./: py32_jacdac_rx_fastpath.s
  group Jacdac/Core
    ../third_party/jacdac-c/source/: jd_util.c jd_io.c jd_control.c jd_physical.c jd_protocol.c jd_services.c jd_send_util.c
    ../third_party/jacdac-c/source/interfaces/: tx_queue.c simple_rx.c event_queue.c
  group Jacdac/Services
    ../third_party/jacdac-c/services/: jd_sensor.c accelerometer.c gyroscope.c jd_status_light.c
  group BSP/py32f002bxx_Start_Kit
    ../third_party/py32f002b-firmware/Drivers/BSP/PY32F002Bxx_Start_Kit/: py32f002bxx_Start_Kit.c
  group Drivers/PY32F002B_HAL_Driver
    ../third_party/py32f002b-firmware/Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_gpio.c py32f002b_hal_pwr.c py32f002b_hal_uart.c py32f002b_hal_i2c.c py32f002b_hal_cortex.c
software components: CMSIS:CORE 5.2.0
